Commit message: fix cmd_vel timeout

File: src/sim_ajk/sim_ajk.urdf (robot description, URDF)
Before this commit: robot sim_ajk, 6 links, 5 joints
Links:
- link base_link: mass 0.500 -> 100.0
- link left_wheel_link: mass 0.500 -> 5.500
- link right_wheel_link: mass 0.500 -> 5.5
